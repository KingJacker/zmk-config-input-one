## config/boards/shields/InputOne/Kconfig.defconfig
```kconfig
if SHIELD_INPUTONE

config ZMK_KEYBOARD_NAME
	default "InputOne"

config SPI
    default y

endif
```
